# Keil uVision project 6020demo.uvprojx, settings and files
target 6020demo (6210000::V6.21::ARMCLANG)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 6020demo +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Application;../Application/GM6020;../Bsp;../Application/Control;../Middleware/FreeRTOS/Inc;../Middleware/FreeRTOS/Portable;../Application/Tasks;../Application/Key;../Application/DM4310
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Inc/: FreeRTOSConfig.h config.h
    ../Core/Src/: main.c gpio.c can.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group GM6020
    ../Application/GM6020/: GM6020.c GM6020.h
  group Bsp
    ../Bsp/: bsp_can.c bsp_can.h
  group Control
    ../Application/Control/: PID.c PID.h
  group FreeRTOS/Src
    ../Middleware/FreeRTOS/Src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Portable
    ../Middleware/FreeRTOS/Portable/: heap_4.c port.c
  group Task
    ../Application/Tasks/: RobotTask.c RobotTask.h
  group Key
    ../Application/Key/: Key.c Key.h
  group DM4310
    ../Application/DM4310/: DM4310.c DM4310.h
software components: CMSIS:CORE 5.6.0
